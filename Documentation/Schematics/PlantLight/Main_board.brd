# Repository Thursdays-Child/PlantLight

File README.md:

# PLANT LIGHT 
### Automatic light switch based on light sensor and date/time

**version 3.0**
Replaced transistor with phototransistor to switch the relay. 

**version 2.0**
Upgraded PCB and logic with ATMega328p and Maxim DS3231M RTC. New schematich and new PCB. The temperature compensated clock
now wakes up the micro once per day, with time of day alarm.

**version 1.2**
Added function to set time from an external input, with all the istructions needed: set draft info on RTC clock.
Linked against new ATTiny CORE library, that has changed the RX and TX pin for serial debug.

**version 1.1**

Added TimeZone library to account for DST (summer time). The TimeZone has been added to the DS1307RTC library,
and slightly modified to remove ARDUINO define, not present in my development environment. 
The timezone rules are saved into an EEPROM image (to save program memory on the small ATTiny85): the image is in 
Intel HEX format.

Library reference at https://github.com/JChristensen/Timezone

**version 1.0**

The project is an automatic switch for 2 LED lamps used to illuminate 
some plants in my house. On board there is a real time clock, to keep track of 
the actual date and time even on power loss, and the light sensor is placed 
on a separate breakout board. A relay switches the main power (230 V AC) to 
the LEDs. The micro is an Atmel ATTiny 85V.

The project is compiled for Atmel AVR, with standard AVR GCC toolchain. 
Eclipse was used to create and compile the projects, with the AVR Plugin.

A makefile is available to compile without Eclispe. 

This project consists of a main C++ file and some libraries (C/C++):

* BH1750FVI: control the light sensor (BH1750) to read the lux value and 
  put to sleep/wake up the sensor;
* DS1307: real time clock library, to read the actual date and time.
* TinyWireM: Wire library modified to work on small ATTiny, were the I2C management 
  hardware is not present. The library uses the internal USI hardware to communicate 
  over serial connection, and implement I2C protocol (reference http://playground.arduino.cc/Code/USIi2c).
* TinySerialDebug: library to use serial communication only for debug purpose 
  on the ATTiny. The configuration allows only 3 fixed speeds (baud/s) and the 
  communication is transmission only from the micro (reference https://code.google.com/archive/p/arduino-tiny/).

The sensors library have been modified to work with the same instance of the 
I2C bus control class, and each functionality has been tested with the hardware. 
The documentation folder contains:

* the bill of material;
* datasheet of used components;
* electrical drawings;

Some pictures can be found at https://goo.gl/photos/P42G4u1Tg8iYygQf6

## EAGLE design Documentation/Schematics/PlantLight/Main_board.brd

Parts:
C1: 100uF; CPOL-RADIAL-10UF-25V
C2: 0.33uF; C050-024X044
C3: 0.1uF; C050-024X044
C4, C5: 0.1uF; C1206
D1: 1N4148; DIODE-1N4148
G2: CR2032AMAZON; CR2032_AMAZON
IC1: 5V; 78XXL
ICSP: AVR_SPI_PROG; 2X3
J1: JACK-PLUG0; SPC4077
JP1: PINHD-1X6; 1X06
OC1: PC817SMD; SMD04
PP: 0; W237-102
R1, R2: 1K; 0207/10
R3, R4, R5, R6, R8: 18K; R1206
R7: 560; R1206
RE1: SRSZ-SL5VDC; SRSZ-SL
T1: 2N5551-NPN-TO92-CBE; TO92-CBE
TIME_MODE: YELLOW; CHIPLED_1206
TIME_MODE_SW: SPST-SMD; TACTILE_SWITCH_SMD_6.0X3.5MM
U3: DS3231M+TRL; 21-0042B_16
U4: ATMEGA8/168/328; TQFP32

Connections:
!INT_SQW: R3.2, U3.3 (!INT/SQW), U4.32 (PD2(INT0))
GND: C1.2 (-), C2.2, C3.2, C4.2, C5.2, G2.-, IC1.GND, ICSP.6, J1.1, JP1.5, T1.E, TIME_MODE.C, TIME_MODE_SW.1, U3.5 (NC_2), U3.6 (NC_3), U3.7 (NC_4), U3.8 (NC_5), U3.9 (NC_6), U3.10 (NC_7), U3.11 (NC_8), U3.12 (NC), U3.13 (GND), U4.3 (GND), U4.5 (GND), U4.21 (GND)
MISO: ICSP.1, U4.16 (PB4(MISO))
MOSI: ICSP.4, U4.15 (PB3(MOSI/OC2))
unnamed: PP.2, RE1.P$6
unnamed: PP.1, RE1.P$12
unnamed: D1.A, RE1.P$1, T1.C
unnamed: R7.1, TIME_MODE.A
unnamed: R7.2, U4.11 (PD7(AIN1))
OC$1: OC1.P$1 (A), R1.2
OC$3: OC1.P$3 (EMIT), T1.B
OC$4: OC1.P$4 (COL), R2.2
RESET: ICSP.5, R6.1, U4.29 (PC6(/RESET))
RE_SW: OC1.P$2 (C), U4.9 (PD5(T1))
SCK: ICSP.3, U4.17 (PB5(SCK))
SCL: JP1.3, R4.2, U3.16 (SCL), U4.28 (PC5(ADC5/SCL))
SDA: JP1.4, R5.2, U3.15 (SDA), U4.27 (PC4(ADC4/SDA))
SER_RX: JP1.2, U4.30 (PD0(RXD))
SER_TX: JP1.1, U4.31 (PD1(TXD))
TIME_MODE_SET: R8.2, TIME_MODE_SW.2, U4.2 (PD4(XCK/T0))
VBAT: G2.+, U3.14 (VBAT)
VCC: C3.1, C4.1, C5.1, D1.C, IC1.OUT, ICSP.2, JP1.6, R1.1, R2.1, R3.1, R4.1, R5.1, R6.2, R8.1, RE1.P$2, U3.2 (VCC), U4.4 (VCC), U4.6 (VCC), U4.18 (AVCC)
VIN: C1.1 (+), C2.1, IC1.IN, J1.3

Notes on the sheet:
LIGHT SWITCH RELAY
L7805CV
VIN 12V
RTC
Voltage regulator
AVR Micro
ICSP
Sensor interface
Relay switch

Board: 2 copper layers, 49.9 x 49.9 mm, 27 parts (8 on the bottom side), 23 nets.

## Commit log

2015-11-28 readme, library code, datasheets, schematics as first version
2015-11-28 Added gitignore files in projects, removed binary folders, updated commenst and readme
2015-11-28 Removed binary folders
2015-11-29 Added light log from SD, modified PCB and generated gerber files
2015-12-31 Added support for mtreg calibration and high resolution mode on the sensor. Added comments in class methods
2015-12-31 Added build conf to gitignore
2015-12-31 Changes for test with complete circuit and manual command
2015-12-31 Changed PCB layout for manufcturing (SeedStudio), added gerber file for PCB factory, added test log with light values in the room
2016-02-06 Added makefile to compile without eclipsse
2016-02-06 Complete rewrite to include drift information on the RTC clock. Drift info will correct the time given the amount of drifted second per day. Added Time standard library to account for leap year etc...
2016-02-06 Added support for new RTC library, with drift info. Tested for 10 days it seems to work. Credit for the library code to https://limchonghan.wordpress.com/driftcorrectedds1307/
2016-02-06 Added drift_test log file, updated readme
2016-02-07 Modified time sync interval to 30 s, to be tested
2016-02-07 Added automatic mode and sampling function, to be completed. Added manual mode with digital input. Added watchdog interval calculation, sensor and micro sleep cycle, corrected RTC driftinfo, to be te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
2016-02-07 Updated version
2016-02-07 Automatic mode splitted in check light and check time functions, removed old comments, unified code in the first cycle of automatic mode.
2016-02-07 Modified time on condition, added gitignore in top directory, removed examples from index
2016-02-07 Remove Example from index
2016-02-07 Fixed gitignore
2016-02-13 Fixed log file init
2016-02-13 Moved SetTime to loop() to be used once with digital input read (more precise). Enabled printDigits to print zero padding in dates (for log purpose). Version 0.6: first version on final PCB
2016-02-13 Added release Eclipse project configuration
2016-02-13 Version 0.6: first on final PCB
2016-02-19 Modified now() functions and some constants to save space for ATTiny85 micro. The system time can't be counted on the micro since in the sleep period the internal millis() timer is off! Sleep mode PO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
2016-02-19 Added new average filter on lux sensor read, used modified time read funtions (now()) with driftinfo saved in the Time library
2016-02-20 Added running average algorithm to compute average lux value, changed digitalaWrite position in manual mode (edge only)
2016-02-20 Changed time/date set
2016-02-20 Removed .dat files, updated partlist table
2016-02-20 Added bianries to gitignore
2016-03-06 Added hysteresis compensation algorithm, enabled light every month, added flag and memory for relay state, added debug information on relay state.
2016-03-06 Modified buffer length to 160 chars.
2016-03-11 Fixed bug in hour condition check
2016-03-11 Added log files and updated LightLog.ods. Release v0.8
2016-03-11 Moved output update at the end of logic, to write only when really needed.
2016-03-12 Increased delay to wait the sensor to be fully awake, after problems with Serial.printlns not called in release configuration.
2016-03-13 Test version v0.9 with Serial.println active: - set longer period to check the current time and added enable/disabled state, this requires less reads on the RTC when the light management is disabled.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
2016-03-13 Added include <avr/iotnx5.h> to avoid indexing problems in Eclipse! (finally!!). Updated version.
2016-03-20 Updated RTC time correction in seconds/day. Cleaned println from code.
2016-10-30 Added TimeZone library to account for DST (summer time). The timezone rules are saved into an EEPROM image in Intel HEX format.
2016-10-30 Small changes to DEBUG flag
2016-10-30 Added TimeZone library to account for DST (summer time).
2016-10-30 Update README and schematic (base Eagle version)
2016-10-31 Final build v1.1: removed comments, added define for EEPROM rules
    address, commented setTime() call.
2016-12-18 Reorganization of cores and library: changed projects includes and link folder. Removed library since it will move to a different repo.
2016-12-18 Reorganization of cores and library: changed projects includes and link folder.
2018-04-30 Moved some components datasheet into new repo
2018-11-02 Fixed linked project name in project cfg.
2018-11-02 Fixed project path in makefile.
2018-11-03 Added define for RX and TX pins (serial debug) for new tiny core. Added function to set time on external input.
2018-11-04 Fixed comment for watch dog mode.
2018-11-18 First commit for v2.0: ATMega368P and BLE
2018-11-18 Removed and ignored backup files for Eagle
2018-11-18 Added new prj configuration for ATMega328P, rewrite of main with new logic a RTC library. First compiling version v2.0b001
2018-11-18 Fixed prj configuration for ATMega 328 (not P). Rewwrite of some functions. Added RTC comunication and watchdog enable/disable (TESTED). Removed prototypes, removed EEPROM image.
2018-11-18 Still prj config problems...
2018-11-20 Updated partlist and readme. Eagle design to be reviewd.
2018-11-24 Moved various functions to new header files in Core, RTC alarm testing in progress. Used new toLocal function to convert utc time to local time.
2018-11-24 Connected NC pins of RTC to ground.
2018-11-27 Review main.cpp code to test 1 second alarm from RTC and watchdog alarm. First working version.
2018-11-29 FIXED RTC ALARM: added RTC.alarm() to reset status flag, and used UTC time for the alarm!!!!!!!!! Removed watchdog. (beta003)
2018-12-01 Added options struct with data loading, used ALARM 2 for the time of day alarm, moved sleep at the end of loop(). To be tested..
2018-12-02 Added "set time mode", function to read date from serial, moved RTC interrupt to external INT0.
2018-12-09 Updated makefile with new library and MCU (and programmer)
2018-12-09 Updated board and schematic with new connections. Removed reset switch and added switch to set time mode. Updated partlist.
2018-12-09 Added timeout on time set mode, enabled light sensors (first test OK), moved logic in loop(), to be tested.
2018-12-11 Reviewed serial output for long test run (SD logging). Changed timeout for set time mode.
2018-12-16 Modified enable and disable hour computation with new methods from TimeZone library.
2018-12-16 Removed options struct, added functions to calculate enable and disable hours and set the RTC alarm.
2018-12-24 Added SERIAL.LOG from test.
2018-12-24 Fixed time mode switch (pull up) in schematic, fixed 1K resistance package.
2018-12-26 Reviewed comment and poll interval for long run test.
2018-12-26 Updated schematich and board with correct simbol for capacitor C3. Updated pdf and gerber file.
2018-12-28 Rebuilt CAM files, sent to SeeedStudio.
2018-12-28 Used correct makeTime() function call to get weekday, added global variables as arguments to various functions, removed debug print
2018-12-28 Added alarm and "utcTime" to checkEnable() function, added comment to clarify the time format.
2019-01-02 Added "disable" message and seconds left in set time mode. Added Alarm_1 reset on time set.
2019-01-19 Changed resistor value, checked available components, new BOM sheet. Converted to Eagle 9.2.2
2019-01-29 Completed partlist
2019-02-11 First build for real PCB, beta 10. Updated project references,
2019-02-16 Updated version, added Release config for 2.0. Final build.
2019-02-16 Update board to v2.1: moved ICSP connector, battery holder to be done.
2019-02-21 Updated board and schematic with optocoupler and NPN transistor
2019-03-10 Uncommented RTC connection, tested.
2019-03-10 Added PC817 SMD package, DC jack, rerouted board.
2019-03-17 Added version number b001, moved text near ICSP connector, converted project to Eagle v9.3.1
2019-03-21 Updated schematic and PCB with 560 Ohm res, used NO contact on relè. Updated partlist.
2019-03-26 Completed ground plain and gerber for production
2020-03-29 Removed project reference and added make target to compile only the main program! main.cpp in test..
2020-03-29 Fixed EL817 optocoupler layout, added 1K resistor and removed transistor base resistor, to be test.
2020-03-29 Renamed R9 -> R2
2020-04-04 Setup test with light sensor emulator..
2020-04-15 Tested with light sensor emulator active.

Notices in the files:
parts and their libraries:
SparkFun-Capacitors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
